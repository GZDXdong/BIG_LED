# IAR project BIG_LED.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx
  ICCARM.CCIncludePath2: CMSIS\Device\ST\STM32F4xx\Include; CMSIS\Include; include; Lib\FreeRTOS\Source\CMSIS_RTOS; Lib\FreeRTOS\Source\include; Lib\FreeRTOS\Source\portable\IAR\ARM_CM4F; Lib\LwIP\src\include; Lib\LwIP\system; Lib\STM32F4xx_HAL_Driver\Inc; source; Lib\LwIP\src\include\lwip; HARDWARE; sys
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: Lib\FreeRTOS\Source\include; include
  OBJCOPY.OOCOutputFile: BIG_LED.hex
  ILINK.IlinkOutputFile: BIG_LED.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: F:\AMAE\BIG_LED\Lib\FreeRTOS\Source\include; F:\AMAE\BIG_LED\Lib\LwIP\src
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: c.out
  group CMSIS/Device/ST/STM32F4xx/Include
    CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h
  group CMSIS/Device/ST/STM32F4xx/Source
    CMSIS/Device/ST/STM32F4xx/Source/: system_stm32f4xx.c
  group CMSIS/Device/ST/STM32F4xx/Source/iar
    CMSIS/Device/ST/STM32F4xx/Source/iar/: startup_stm32f407xx.s
  group HARDWARE
    HARDWARE/: led.c led.h
  group include
    include/: main.h stm32f4xx_it.h udpclient.h
    source/: udpserver.h
  group Lib/FreeRTOS/Source
    Lib/FreeRTOS/Source/: croutine.c event_groups.c httpserver-socket.c list.c queue.c tasks.c timers.c
  group Lib/FreeRTOS/Source/CMSIS_RTOS
    Lib/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c cmsis_os.h
  group Lib/FreeRTOS/Source/include
    Lib/FreeRTOS/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h httpserver-socket.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group Lib/FreeRTOS/Source/portable/IAR/ARM_CM4F
    Lib/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group Lib/FreeRTOS/Source/portable/MemMang
    Lib/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Lib/LwIP/src/api
    Lib/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Lib/LwIP/src/core
    Lib/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Lib/LwIP/src/core/ipv4
    Lib/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Lib/LwIP/src/core/ipv6
    Lib/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group Lib/LwIP/src/include/lwip
    Lib/LwIP/src/include/lwip/: api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip_addr.h lwipopts.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpip.h timeouts.h udp.h
  group Lib/LwIP/src/include/lwip/apps
    Lib/LwIP/src/include/lwip/apps/: fs.h httpd.h httpd_opts.h lwiperf.h mdns.h mdns_opts.h mdns_priv.h mqtt.h mqtt_opts.h netbiosns.h netbiosns_opts.h snmp.h snmp_core.h snmp_mib2.h snmp_opts.h snmp_scalar.h snmp_table.h snmp_threadsync.h snmpv3.h sntp.h sntp_opts.h tftp_opts.h tftp_server.h
  group Lib/LwIP/src/include/lwip/priv
    Lib/LwIP/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h nd6_priv.h tcp_priv.h tcpip_priv.h
  group Lib/LwIP/src/include/lwip/prot
    Lib/LwIP/src/include/lwip/prot/: autoip.h dhcp.h dns.h etharp.h ethernet.h icmp.h icmp6.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group Lib/LwIP/src/include/netif
    Lib/LwIP/src/include/netif/: etharp.h ethernet.h lowpan6.h lowpan6_opts.h slipif.h
  group Lib/LwIP/src/include/netif/ppp
    Lib/LwIP/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group Lib/LwIP/src/include/netif/ppp/polarssl
    Lib/LwIP/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group Lib/LwIP/src/include/posix
    Lib/LwIP/src/include/posix/: errno.h netdb.h
  group Lib/LwIP/src/include/posix/sys
    Lib/LwIP/src/include/posix/sys/: socket.h
  group Lib/LwIP/src/netif
    Lib/LwIP/src/netif/: ethernet.c ethernetif.c lowpan6.c slipif.c
  group Lib/LwIP/src/netif/ppp
    Lib/LwIP/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group Lib/LwIP/src/netif/ppp/polarssl
    Lib/LwIP/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
  group Lib/LwIP/system/arch
    Lib/LwIP/system/arch/: bpstruct.h cc.h cpu.h epstruct.h init.h lib.h perf.h sys_arch.h
  group Lib/LwIP/system/OS
    Lib/LwIP/system/OS/: sys_arch.c
  group Lib/STM32F4xx_HAL_Driver/Inc
    Lib/STM32F4xx_HAL_Driver/Inc/: stm32_assert.h stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_cec.h stm32f4xx_hal_conf.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dfsdm.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dsi.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_lptim.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_mmc.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_adc.h stm32f4xx_ll_bus.h stm32f4xx_ll_cortex.h stm32f4xx_ll_crc.h stm32f4xx_ll_dac.h stm32f4xx_ll_dma.h stm32f4xx_ll_dma2d.h stm32f4xx_ll_exti.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_gpio.h stm32f4xx_ll_i2c.h stm32f4xx_ll_iwdg.h stm32f4xx_ll_lptim.h stm32f4xx_ll_pwr.h stm32f4xx_ll_rcc.h stm32f4xx_ll_rng.h stm32f4xx_ll_rtc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_spi.h stm32f4xx_ll_system.h stm32f4xx_ll_tim.h stm32f4xx_ll_usart.h stm32f4xx_ll_usb.h stm32f4xx_ll_utils.h stm32f4xx_ll_wwdg.h
  group Lib/STM32F4xx_HAL_Driver/Src
    Lib/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_timebase_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group source
    source/: main.c stm32f4xx_it.c udpclient.c udpserver.c
  group sys/inc
    sys/: delay.h sys_macro.h
  group sys/src
    sys/: delay.c
